# Keil uVision project RTX_CM.uvprojx, settings and files
target CM0_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM0 (library)
  AfterMake: cmd.exe /C copy CM0_LE\libRTX_CM0.a ..\.
  group Core
    ../../../Source/: rtx_kernel.c rtx_thread.c rtx_delay.c rtx_timer.c rtx_evflags.c rtx_mutex.c rtx_semaphore.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_system.c rtx_evr.c
    ../../../../Source/: os_systick.c
  group Handlers
    ../../../Source/GCC/: irq_cm0.S irq_cm3.S irq_cm4f.S irq_armv8mbl.S irq_armv8mml.S
target CM3_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy CM3_LE\libRTX_CM3.a ..\.
target CM4F_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM4F (library)
  AfterMake: cmd.exe /C copy CM4F_LE\libRTX_CM4F.a ..\.
target ARMv8MBL_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MBL") CLOCK(12000000) ELITTLE
  output: RTX_V8MB (library)
  AfterMake: cmd.exe /C copy ARMv8MBL_LE\libRTX_V8MB.a ..\.
target ARMv8MBL_NS_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: as above
  output: RTX_V8MBN (library)
  AfterMake: cmd.exe /C copy ARMv8MBL_NS_LE\libRTX_V8MBN.a ..\.
target ARMv8MML_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") CLOCK(12000000) ELITTLE
  output: RTX_V8MM (library)
  AfterMake: cmd.exe /C copy ARMv8MML_LE\libRTX_V8MM.a ..\.
target ARMv8MML_NS_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: as above
  output: RTX_V8MMN (library)
  AfterMake: cmd.exe /C copy ARMv8MML_NS_LE\libRTX_V8MMN.a ..\.
target ARMv8MML_SP_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: RTX_V8MMF (library)
  AfterMake: cmd.exe /C copy ARMv8MML_SP_LE\libRTX_V8MMF.a ..\.
target ARMv8MML_SP_NS_LE (6050000::V6.5::.\ARMCLANG_6.5)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.0.2-dev4
  cpu: as above
  output: RTX_V8MMFN (library)
  AfterMake: cmd.exe /C copy ARMv8MML_SP_NS_LE\libRTX_V8MMFN.a ..\.
software components: CMSIS:CORE 5.0.0
